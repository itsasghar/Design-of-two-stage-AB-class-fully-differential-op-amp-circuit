********************Project2**********************
********************Libraries*********************
.lib	'mm018.l'	TT
********************Parameters********************
********************Mosfets***********************
M1		1		22		2		0		nch		W=93.83u		L=0.4u
M2		3		23		2		0		nch		W=93.83u		L=0.4u
M3		5		4		1		0		nch		W=93.83u		L=0.4u
M4		6		4		3		0		nch		W=93.83u		L=0.4u
M5		5		7		8		100		pch		W=140.75u		L=0.4u
M6		6		7		9		100		pch		W=140.75u		L=0.4u
M7		8		10		100		100		pch		W=140.75u		L=0.4u
M8		9		10		100		100		pch		W=140.75u		L=0.4u
M9		16		6		0		0		nch		W=187.63uu		L=0.4u
M10		16		16		100		100		pch		W=281.5u		L=0.4u
M11		11		5		0		0		nch		W=187.63uu		L=0.4u
M12		13		12		11		0		nch		W=187.63u		L=0.4u
M13		13		14		15		100		pch		W=281.5u		L=0.4u
M14		15		16		100		100		pch		W=281.5u		L=0.4u
M15		20		5		0		0		nch		W=187.63u		L=0.4u
M16		20		20		100		100		pch		W=281.5u		L=0.4u
M17		17		6		0		0		nch		W=187.63uu		L=0.4u
M18		18		24		17		0		nch		W=187.63u		L=0.4u
M19		18		25		19		100		pch		W=281.5u		L=0.4u
M20		19		20		100		100		pch		W=281.5u		L=0.4u
M22		2		6		0		0		nch		W=93.83u		L=0.4u
M23		2		5		0		0		nch		W=93.83u		L=0.4u
Cl1		13		0		3.5p
cl2		18		0		3.5p
Cc1		6		18		5.12p
Cc2		5		13		5.12p
********************Power Supplies********************
VDD		100	0	1.8
Vb1		4	0	1.1
Vb2		7	0	0.85
Vb3		10	0	1.12
Vb4		12	0	0.95
Vb5		14	0	0.84
Vb6		24	0	0.95
Vb7		25	0	0.84

Vin1	22	0 	 	DC		0.9		Ac	1	0
Vin2	23	0 		DC		0.9		Ac 	1	180
********************Analysis**************************
.OP
.tf V(18,13)	vin2
.ac		DEC		10		1		10G
.print	ac	gain=par('(v(13))')
.end
